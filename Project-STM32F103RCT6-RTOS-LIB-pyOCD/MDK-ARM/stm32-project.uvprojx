# Keil uVision project stm32-project.uvprojx, settings and files
target stm32-project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32-project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,ARM_MATH_CM3
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\UserApp;..\UserApp\Lib\FreeRTOS\include;..\UserApp\Lib\FreeRTOS\portable\RVDS\ARM_CM3;..\UserApp\Lib\CMSIS\DSP\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/source
    ../UserApp/Lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c croutine.c
  group FreeRTOS/portable
    ../UserApp/Lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../UserApp/Lib/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group CMSIS/DSP
    $TC_ROOT$/../../Users/Q/Desktop/test/Project-STM32F103RCT6-pyOCD/UserApp/Lib/CMSIS/DSP/lib/ARM/: arm_cortexM3l_math.lib
  group UserApp
    ../UserApp/: user_main.c
software components: CMSIS:CORE 5.6.0
